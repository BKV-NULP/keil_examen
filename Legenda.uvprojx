# Keil uVision project Legenda.uvprojx, settings and files
target Legenda (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Legenda
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Library\Systems\Include;..\Legendarne_Zavdanna;.\Library\Import\Include;.\Application\Inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Systems files
    ./Library/Systems/Source/: system_LPC17xx.c startup_LPC17xx.s
  group Include
    ./Library/Import/Source/: debug_frmwrk.c lpc17xx_gpio.c lpc17xx_pinsel.c lpc17xx_uart.c lpc17xx_clkpwr.c lpc17xx_libcfg_default.c lpc17xx_adc.c lpc17xx_dac.c lpc17xx_gpdma.c lpc17xx_pwm.c lpc17xx_i2c.c
  group Application
    ./Application/Src/: adc.c dac.c gpio.c memory.c parser.c pwm.c terminal.c time.c
  group Users
    ./Users/: main.c
software components: CMSIS:CORE 5.3.0
